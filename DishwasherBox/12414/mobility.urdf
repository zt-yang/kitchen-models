Commit message: dishwasher

File: DishwasherBox/12414/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_uc96ccf13-0360-49f7-885b-0efdae244728, 3 links, 2 joints
Joints:
- joint joint_1: limit lower=0.0 upper=1.5707963267948966 -> (none); type revolute -> fixed
